NETWORK_MANAGER:mender-image = "systemd"
