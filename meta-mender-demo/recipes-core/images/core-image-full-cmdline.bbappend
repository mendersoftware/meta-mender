MENDER_DATA_PART_DIR = "${DEPLOY_DIR_IMAGE}/persist"
IMAGE_INSTALL_append = " hello-mender"
