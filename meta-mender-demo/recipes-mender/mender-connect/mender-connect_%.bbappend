MENDER_CONNECT_USER ?= "root"
