MENDER_SHELL_USER ?= "root"
