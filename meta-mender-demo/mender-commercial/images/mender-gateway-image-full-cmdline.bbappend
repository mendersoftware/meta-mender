IMAGE_INSTALL:append = " mender-gateway-doc"
