require recipes-extended/images/core-image-full-cmdline.bb

IMAGE_INSTALL:append = " mender-monitor"
