SRC_URI_remove = "file://0006-env-Kconfig-Add-descriptions-so-environment-options-.patch"
SRC_URI_append = " file://0005-fw_env_main.c-Fix-incorrect-size-for-malloc-ed-strin.patch \
                   file://u-boot_v2016.11-backport-of-34255b92e6e68941ab1134299faa86acc5a1abc8.patch"
