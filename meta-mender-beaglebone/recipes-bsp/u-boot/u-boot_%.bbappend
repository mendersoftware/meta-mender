require u-boot-beaglebone.inc
