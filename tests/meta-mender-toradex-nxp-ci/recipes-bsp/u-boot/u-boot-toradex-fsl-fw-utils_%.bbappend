require u-boot-mender-toradex-nxp-ci.inc
