RDEPENDS_${PN}_append_mender-testing-enabled = " \
    mender-qa \
    "