RDEPENDS:${PN}:append:rpi = " rpi-u-boot-scr"
