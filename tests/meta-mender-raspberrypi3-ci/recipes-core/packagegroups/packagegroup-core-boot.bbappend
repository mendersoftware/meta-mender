RDEPENDS:${PN}:append:mender-testing-enabled = " \
    mender-qa \
    "
