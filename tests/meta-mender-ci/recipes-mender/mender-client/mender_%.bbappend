require mender-client-ci.inc
