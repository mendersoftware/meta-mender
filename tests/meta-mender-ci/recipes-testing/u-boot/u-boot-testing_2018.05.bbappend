# Remove this block when moving from dunfell to the next branch, and also remove
# the bundled version of u-boot_2021.07.
SRC_URI:remove = "file://0001-Reintroduction-will-make-a-better-message-after-I-ha.patch"
