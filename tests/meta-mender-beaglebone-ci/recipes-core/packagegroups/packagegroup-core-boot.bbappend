RDEPENDS_${PN}_append = " \
    mender-qa \
    "