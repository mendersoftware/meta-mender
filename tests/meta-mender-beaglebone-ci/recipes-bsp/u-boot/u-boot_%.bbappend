FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI_append = " file://reenable_uenvcmd.patch"
