require u-boot-mender-dragonboard-410c.inc
