# Global variables
DISTRO_FEATURES:append = " wifi"

IMAGE_INSTALL:append = " iw wpa-supplicant linux-firmware-bcm43430 packagegroup-base"

ENABLE_UART = "1"

