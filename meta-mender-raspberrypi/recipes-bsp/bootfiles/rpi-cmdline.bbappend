include ${@mender_feature_is_enabled("mender-client-install","rpi-cmdline-mender.inc","",d)}
