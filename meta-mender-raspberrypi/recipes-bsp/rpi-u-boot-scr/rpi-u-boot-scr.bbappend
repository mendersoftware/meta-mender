FILESEXTRAPATHS:prepend_rpi_mender-client-install := "${THISDIR}/files:"
