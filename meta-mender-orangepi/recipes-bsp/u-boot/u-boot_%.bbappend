# This file is to properly patch u-boot before the Orange Pi distro u-boot was converted into u-boot-opi.
# In newer versions, u-boot-opi_%.bbappend is used.
require u-boot-orangepi.inc
