require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=1.0.x"

# Tag: 1.0.0
SRCREV = "90fa13bfb57a6c0460e27c90f3f4dd1de604c789"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LIC_FILES_CHKSUM.sha256;md5=f4a3edb2a8fe8e2ecde8062ba20b1c86"
