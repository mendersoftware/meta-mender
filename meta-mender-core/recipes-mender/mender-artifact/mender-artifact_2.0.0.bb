require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=2.0.x"

# Tag: 2.0.0
SRCREV = "ca7e566949c796bf30ee79f9c680877ff4fc2e04"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://src/github.com/mendersoftware/mender-artifact/LIC_FILES_CHKSUM.sha256;md5=f4a3edb2a8fe8e2ecde8062ba20b1c86"
