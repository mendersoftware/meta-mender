require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=2.1.x"

# Tag: 2.1.0
SRCREV = "dbed5177b39a36307618ea9be029952140530500"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://src/github.com/mendersoftware/mender-artifact/LIC_FILES_CHKSUM.sha256;md5=1baf9ba39aca12f99a87a99b18440e84"
