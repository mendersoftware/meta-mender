require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=2.0.x"

# Tag: 2.0.1
SRCREV = "1e53ee16ca2a8a1c5d0a331abf4c41d57711c3a5"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://src/github.com/mendersoftware/mender-artifact/LIC_FILES_CHKSUM.sha256;md5=70480461e7f35d34bbc0b27e02b87311"
