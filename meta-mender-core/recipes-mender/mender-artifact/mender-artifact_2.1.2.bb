require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=2.1.x"

# Tag: 2.1.2
SRCREV = "b8e1e0b2865e0dc06c69ef61b110d4c26aa1736e"

LICENSE = "Apache-2.0 & BSD-2-Clause & BSD-3-Clause & ISC & MIT"
LIC_FILES_CHKSUM = "file://src/github.com/mendersoftware/mender-artifact/LIC_FILES_CHKSUM.sha256;md5=1baf9ba39aca12f99a87a99b18440e84"
