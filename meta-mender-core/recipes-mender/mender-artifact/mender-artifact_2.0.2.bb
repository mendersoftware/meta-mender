require mender-artifact.inc

SRC_URI = "git://github.com/mendersoftware/mender-artifact.git;protocol=https;branch=2.0.x"

# Tag: 2.0.2
SRCREV = "24dcd83582e5c1258e36860a528e803529ad237f"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://src/github.com/mendersoftware/mender-artifact/LIC_FILES_CHKSUM.sha256;md5=70480461e7f35d34bbc0b27e02b87311"
