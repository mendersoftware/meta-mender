DEPENDS:remove:mender-systemd-boot = "grub grub-efi grub-efi-native"
DEPENDS:remove:mender-uboot = "grub grub-efi grub-efi-native"
