FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI_append = " file://0001-Do-not-use-metadata_csum-feature-on-ext4-by-default.patch"
