require u-boot-common_2020.01.inc
require u-boot_2020.01.inc

DEPENDS += "bc-native dtc-native"
