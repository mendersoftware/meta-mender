include grub-mender-grubenv.inc

# Tag: 1.2.1
SRCREV = "a4eff9b83c322a9371c8e4cc67de97281c7c2847"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a63d325b69180ec25a59e045c06ec468"
