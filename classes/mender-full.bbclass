inherit mender-boot
inherit mender-image
inherit mender-install
