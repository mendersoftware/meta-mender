include mender-test-files.inc
