require mender-client-test-files-3.x.inc
