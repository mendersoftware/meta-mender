DEPENDS:append:mender-auth-install = " p11-kit"

SRCREV:mender-auth-install = "e1210903291b1de9eabcad26e740a4b2fbcca692"
