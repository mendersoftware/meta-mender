DEPENDS_remove_vexpress-qemu-flash = "openssl"
DEPENDS_append_vexpress-qemu-flash = " openssl10"
