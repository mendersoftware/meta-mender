DEPENDS_remove = "openssl"
DEPENDS_append = " openssl10"
