SRC_URI_append_vexpress-qemu_mender-grub = " \
    file://0001-vexpress_ca9x4-Enable-use-of-correct-DTB-file-and-re.patch \
"
