require monitor-client.inc

# TODO: Prioritize after 1.0.0 release
# Downprioritize this recipe in version selections.
DEFAULT_PREFERENCE = "-1"
