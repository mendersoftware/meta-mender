require monitor-client.inc

PV = "master-git"

# Skip version check
MENDER_DEVMODE = "true"

# TODO: Downprioritize after 1.0.0 release
# Downprioritize this recipe in version selections.
#DEFAULT_PREFERENCE = "-1"
